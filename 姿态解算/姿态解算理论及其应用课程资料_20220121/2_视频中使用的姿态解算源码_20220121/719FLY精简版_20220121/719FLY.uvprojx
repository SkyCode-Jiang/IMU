# Keil uVision project 719FLY.uvprojx, settings and files
target stm32飞控V1.0 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32飞控V1.0 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: .\Drive\inc;.\IMU;.\CONTROL;.\COMMUNICATE;.\Math;.\Drive\inc;.\IMU
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./USER/: main.c scheduler.c
  group DRIVE
    ./Drive/src/: led.c delay.c tim.c nvic.c motor.c mpu6050.c system.c oled.c
  group IMU
    ./IMU/: filter.c imu.c structconfig.h kalman.c
  group CONTROL
    ./CONTROL/: pid.c control.c
  group COMMUNICATION
    ./Drive/src/: usart.c RC.c iic.c
    ./COMMUNICATE/: ANO_DT.c ANO_DT.h
  group Math
    ./Math/: myMath.c
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
