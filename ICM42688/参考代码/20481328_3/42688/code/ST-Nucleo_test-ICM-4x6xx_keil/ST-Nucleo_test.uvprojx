# Keil uVision project ST-Nucleo_test.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F411RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ST-Nucleo_test
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F411xE,USE_STDPERIPH_DRIVER,ASSERT,NDEBUG,NUCLEO,INV_MSG_ENABLE
  c include: .\board-hal;.\Invn\Utils;.\Invn\EmbUtils;.\stm32f4x\CMSIS\Core;.\stm32f4x\CMSIS\Device;.\stm32f4x\STM32F4xx_StdPeriph_Driver\inc;.\RTE\Device\STM32F411RETx;..\ST-Nucleo_test-ICM-4x6xx_keil
  asm define: STM32F411xE,USE_STDPERIPH_DRIVER,ASSERT,NDEBUG,NUCLEO,INV_MSG_DISABLE
  asm include: .\board-hal;.\stm32f4x\CMSIS\Core;.\stm32f4x\STM32F4xx_StdPeriph_Driver\inc;.\RTE\Device\STM32F411RETx;.\Invn\Utils;..\ST-Nucleo_test-ICM-4x6xx_keil
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Header
    ./Invn/Devices/Drivers/Ak0991x/: Ak0991x.h Ak0991xSerif.h
    ./stm32f4x/CMSIS/Core/: arm_common_tables.h arm_const_structs.h arm_math.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSimd.h core_sc000.h core_sc300.h
    ./Invn/Utils/: DataConverter.h ErrorHelper.h
    ./board-hal/: dbg_gpio.h delay.h uart.h timer.h system.h sys_timer.h stm32f4xx_it.h spi_slave.h spi_master.h rtc_timer.h led.h i2c_master.h gpio.h
    ./Invn/Devices/: Device.h DeviceAggregator.h DeviceAk0991x.h DeviceEmdWrapper.h DeviceIcm20690.h DeviceSmartMotion.h HostSerif.h SensorConfig.h SensorTypes.h SerifHal.h VSensorId.h
    ./Invn/Devices/Drivers/Icm20690/: Icm20690Transport.h Icm20690Setup.h Icm20690Serif.h Icm20690SelfTest.h Icm20690Defs.h Icm20690Ctrl.h Icm20690AuxTransport.h Icm20690AuxCompassAkm.h Icm20690.h
    ./Invn/: IDDVersion.h InvBool.h InvError.h InvExport.h
    ./Invn/Devices/Drivers/IddWrapper/: IddWrapperTransportUart.h IddWrapperTransport.h IddWrapperProtocol.h
    ./Invn/EmbUtils/: InvFormat.h InvCksum.h InvBits.h InvBasicMath.h InvAssert.h CBinaryWriter.h CBinaryReader.h UartTxEmulator.h RingByteBuffer.h RingBuffer.h Logger.h InvString.h InvScheduler.h InvQueue.h InvProtocol.h InvPrintf.h InvList.h
    ./stm32f4x/STM32F4xx_StdPeriph_Driver/inc/: misc.h stm32f4xx_adc.h stm32f4xx_can.h stm32f4xx_cec.h stm32f4xx_crc.h stm32f4xx_cryp.h stm32f4xx_dac.h stm32f4xx_dbgmcu.h stm32f4xx_dcmi.h stm32f4xx_dma.h stm32f4xx_dma2d.h stm32f4xx_dsi.h stm32f4xx_exti.h stm32f4xx_flash.h stm32f4xx_flash_ramfunc.h stm32f4xx_fmpi2c.h stm32f4xx_gpio.h stm32f4xx_hash.h stm32f4xx_i2c.h stm32f4xx_iwdg.h stm32f4xx_lptim.h stm32f4xx_ltdc.h stm32f4xx_pwr.h stm32f4xx_qspi.h stm32f4xx_rcc.h stm32f4xx_rng.h stm32f4xx_rtc.h stm32f4xx_sai.h stm32f4xx_sdio.h stm32f4xx_spdifrx.h stm32f4xx_spi.h stm32f4xx_syscfg.h stm32f4xx_tim.h stm32f4xx_usart.h stm32f4xx_wwdg.h
    ./Invn/VSensor/: VSensorVersion.h VSensorType.h VSensorSmartListener.h VSensorListener.h VSensorEvent.h VSensorData.h VSensorConfig.h VSensor.h
    ./examples/STnucleo_test/: Icm406xxTransport.h Icm406xxSelfTest.h Icm406xxExtFunc.h Icm406xxDriver_HL.h Icm406xxDefs.h ICM-4x6xx.h example-selftest.h common.h
    ./stm32f4x/CMSIS/Device/: stm32f4xx.h stm32f4xx_conf.h system_stm32f4xx.h
  group stm32f4x
    ./stm32f4x/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group example
    ./examples/STnucleo_test/: ErrorHelper.c ICM-4x6xx.c Icm406xxDriver.c Icm406xxDriver_HL.c Icm406xxSelfTest.c Icm406xxTransport.c example_testapp.c example-selftest.c
    ./board-hal/: dbg_gpio.c delay.c gpio.c i2c_master.c iar_hook.c led.c spi_master.c spi_slave.c stm32f4xx_it.c sys_timer.c timer.c uart.c rtc_timer.c
    ./Invn/Utils/: DataConverter.c Message.c
    ./Invn/EmbUtils/: InvBasicMath.c InvCksum.c InvFormat.c InvList.c InvPrintf.c Logger.c RingByteBuffer.c UartTxEmulator.c
    ./Invn/Devices/: HostSerif.c Sensor.c
software components: CMSIS:CORE 5.1.2, Device:Startup 2.1.0
